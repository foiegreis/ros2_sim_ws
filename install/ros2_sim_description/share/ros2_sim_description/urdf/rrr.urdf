Commit message: xacro commit

File: install/ros2_sim_description/share/ros2_sim_description/urdf/rrr.urdf (robot description, URDF)
Before this commit: robot rrr_description, 8 links, 7 joints
Joints:
- joint link3_gripper_joint: origin xyz=0 0 1.0 rpy=0 -1.57 0 -> xyz=0 0 1.0 rpy=0 0 0
